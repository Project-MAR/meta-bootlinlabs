IMAGE_INSTALL:append = " dropbear"
IMAGE_INSTALL:append = " ninvaders"