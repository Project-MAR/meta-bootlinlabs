SUMMARY = "Example image"
IMAGE_INSTALL = "packagegroup-core-boot dropbear ninvaders"
IMAGE_LINGUAS = " "
inherit core-image
